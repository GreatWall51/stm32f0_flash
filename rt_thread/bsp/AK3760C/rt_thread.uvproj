# Keil uVision project rt_thread.uvproj, settings and files
target ak_rt_thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT91SAM9260 Microchip
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x300FFF) IROM(0x100000-0x107FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: rt_thread
  AfterMake: fromelf --bin !L --output rt_thread.bin
  AfterMake: cpstool.exe rt_thread.bin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARM_LIBC
  c include: ..\..\include;..\..\include\libc;..\..\libcpu\arm\ak3760c;..\..\libcpu\arm\common;..\..\components\libc\armlibc;..\..\components\libc\pthreads;..\..\components\drivers\include;..\..\components\finsh;..\AK3760C;.\applications;.\config;.\drivers;.\platform
  asm misc: --cpreproc
  asm include: .\platform
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT4: ROM 0x100000 size 0x8000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x1000
  scatter file: .\link_scripts\sdram.scat
  link misc: --keep *.o(FSymTab)
  group Application
    ./applications/: application.c startup.c
  group Drivers
    ./drivers/: board.c usart.c led.c watchdog.c
  group platform
    ./platform/: gpio.c interrupt.c reset.c rt_low_level_init.c system_clock.c timer.c l2.c
  group libcpu
    ../../libcpu/arm/ak3760c/: cpuport.c mmu.c stack.c trap.c context_rvds.S start_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group libc
    ../../components/libc/compilers/armlibc/: mem_std.c stubs.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finish
    ../../components/finsh/: cmd.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
